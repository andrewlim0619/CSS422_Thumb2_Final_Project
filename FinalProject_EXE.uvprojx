# Keil uVision project FinalProject_EXE.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C129XNCZAD Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FinalProject_EXE
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src
    ./Thumb2_Programs/: heap.s stdlib.s svc.s timer.s
    ./C_Programs/: driver_keil.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
